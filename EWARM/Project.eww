<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32WB55_BLE_HeartRate_Client.ewp</path>
  </project>
  <batchBuild />
</workspace>
